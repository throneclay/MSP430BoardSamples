# IAR project DS1302.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F149 MSP430F149
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F149.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 1
  group (top)
    ./: main.c
  group button
    ../common/button/: button.c button.h
  group ds1302
    ../common/ds1302/: ds1302.c ds1302.h
  group SMG
    ../common/SMG/: SMG.c SMG.h
  group sys
    ../common/sys/: sys.c sys.h
